## boards/shields/firstkb/Kconfig.defconfig
```kconfig
if SHIELD_FIRSTKB

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "firstkb"

endif
```
